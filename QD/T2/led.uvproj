# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: led +hex
  c flags: Optimize=9 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 shared.c adc.c display.c sync.c uart.c com_1.c lm567.c nRF24L01.c
