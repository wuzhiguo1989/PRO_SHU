# Keil uVision project lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W1K16S STC
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: lock +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 sync.c main.c task.c key.c led.c pwm.c display.c power.c lm567.c usart.c
