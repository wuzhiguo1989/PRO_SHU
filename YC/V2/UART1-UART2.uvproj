# Keil uVision project UART1-UART2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: EM08 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: extension.c main.c putchar.c task.c uart.c workflow.c adc.c alert.c dwscreen.c e2prom.c process.c
