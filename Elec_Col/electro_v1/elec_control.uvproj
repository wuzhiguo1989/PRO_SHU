# Keil uVision project elec_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: elec_control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 tm1727.c jl17467pqw.c main.c share.c adc.c sync.c task.c usart.c light.c time.c control.c e2prom.c signal.c beep.c
